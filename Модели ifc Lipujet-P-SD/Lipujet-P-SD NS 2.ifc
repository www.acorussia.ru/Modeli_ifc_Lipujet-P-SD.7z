Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView]
Time: 2017-05-23T09:56:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 23 09:56:36 2017 * Host: IN-BLR-PC-0012 * Database: C:\Users\palleri\AppData\Local\Temp\{33E315EE-B1F1-476A-BFE4-1FFB5943F612}\ifc * Database version: 5507 * Database creation date: Tue May 23 09:56:35 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 23 09:56:35 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 23 09:56:35 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: NS2, ME_PE_ecojet gd extension stage 1_ACO:NS2:7193
In: Level 1
Type - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; PredefinedType: GREASEINTERCEPTOR; Material: HDPE, Black, Plastic, White, HDPE, Red, HDPE, Grey
Type - General - instructions_for_use: http://katalog.aco-haustechnik.de/ilcatalogue/download/ZG9jdW1lbnQvZG93bmxvYWQucGRmL2RlL0VCQV9FQ08tSkVUX0dHRF9fNDUwMDIucGRm/EBA_ECO-JET_GGD__45002.pdf; RSen_C_code_ETIM: EC010271; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_info_technical: http://katalog.aco-haustechnik.de/Home/Produkte/Clean/Fettabscheider/Freiaufstellung/Vollentsorgung/Geteilte-Bauform-Polyethylen-PE-HD/Eco-Jet-GD-Ausbaustufe-1; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: Grease separator plant as per DIN EN 1825 and DIN 4040-100; LOD: LOD 400; Manufacturer: ACO; Model: NS 2; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Building Supervisory Authority approval Z-54.1-414; Type Name: NS2
Type - Materials and Finishes - RSen_C_material: HDPE, Grey; RSen_C_material_01: HDPE, Black
Type - Other - Category: Mechanical Equipment; Family Name: ME_PE_ecojet gd extension stage 1_ACO
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: NS2
Constraints - clearance_zone: no; DN_sanitary: no; left: no; logo: yes; OD_sanitary: yes; Offset: 0 mm; right: yes
Dimensions - A: 510 mm; Area: 14.519 m2; B: 660 mm; D: 110 mm; DN: 100 mm; H: 1200 mm; H1: 930 mm; H2: 1000 mm; H3: 1350 mm; H4: 219 mm; L1: 1180 mm; L2: 1360 mm; Volume: 0.831902 m3; W1: 700 mm
General - RSen_P_c01_diameter: 110 mm; RSen_P_c02_diameter: 110 mm; RSen_P_c03_diameter: 65 mm
Identity Data - Mark: 2; RSen_C_code_article: 3802.50.00; RSen_C_code_gtin: 04002626132451; RSen_C_description: ACO Fettabscheid. Eco-Jet G NS2 teilbar m. Direktabsaugung
Mechanical - System Classification: Sanitary,Other
Model Properties - clearance_back: 400 mm; clearance_entry: 1680 mm; clearance_exit: 680 mm; clearance_front: 950 mm; clearance_top: 1950 mm; D_drain: 76 mm; DN_drain: 65 mm; drain_X: 37.5 mm; drain_Y: 280.8 mm; drain_Z: 1225 mm
Other - extension_stage_lookup_table_name: ecojet_gd_extension_stage_1; Family: ME_PE_ecojet gd extension stage 1_ACO: NS2; Family and Type: ME_PE_ecojet gd extension stage 1_ACO: NS2; H_tank: 981 mm; L2_half: 680 mm; lookup_table_name: ecojet_g_basic; R: 55 mm; R1: 350 mm; Type: ME_PE_ecojet gd extension stage 1_ACO: NS2; Type Id: ME_PE_ecojet gd extension stage 1_ACO: NS2
Phasing - Phase Created: New Construction
Plumbing - grease_store_capacity: 0.08 m3; overall_capacity: 0.48 m3; sludge_trap_capacity: 0.21 m3
Structural - RSen_S_gross_mass: 555; RSen_S_net_mass: 75
